# Keil uVision project gyro.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.2.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: gyro (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: Gyro.c
software components: CMSIS:CORE 4.1.0, nRF_Drivers:nrf_delay 3.0.0, nRF_Drivers:nrf_gpio 3.0.0, nRF_Drivers:twi_master 3.0.0
